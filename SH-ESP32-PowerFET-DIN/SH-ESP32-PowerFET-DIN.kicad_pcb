# Repository KEGustafsson/yacht_hardware

## KiCad design SH-ESP32-PowerFET-DIN/SH-ESP32-PowerFET-DIN.kicad_pcb

Board: 4 copper layers, 234.0 x 256.6 mm, 99 parts (2 on the bottom side), 63 nets, no tracks yet.

Parts:
C101, C102, C103, C104: 1nf; C_0402_1005Metric
C201, C202, C203, C204, C205, C206, C301, C401, C501, C601: 100nF; C_0402_1005Metric
C701: 2.2uF/50V; C_0805_2012Metric
C702: 10nF/50V; C_0402_1005Metric
C703: 2.2uF/16V; C_0603_1608Metric
D101: RED LED; LED_0603_1608Metric
D301, D401, D501, D601: BLUE LED; LED_0603_1608Metric
D302, D402, D502, D602: SM4007PL; D_SOD-123F
D701: SMBJ33CA; D_SMB
D703: B5819W; D_SOD-123
F701: FSMD012-1206-R; Fuse_1206_3216Metric
FB701: GZ2012D601TF; L_0805_2012Metric
J101: DBT50G-9.5-4P; Connector_9.5mm_ScrewTerminal_4
J102: DBT50G-9.5-2P; Connector_9.5mm_ScrewTerminal_4
J103: AddressSelect; PinHeader_2x04_P2.54mm_Vertical_ReducedCY_Jumper
J105: UPDI; PinHeader_1x02_P2.54mm_Vertical
J106: I2C; PinSocket_1x04_P2.54mm_Vertical
J107, J108, J110, J111: Switch; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J109: I2C; PinHeader_1x04_P2.54mm_Vertical-ShrunkCY
J701: VIN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J702: VOUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J703: VOUT; PinSocket_1x02_P2.54mm_Vertical
Q301, Q401, Q501, Q601: IRLML0030; SOT-23
Q302, Q402, Q502, Q602: IRF5210STRLPBF; TO-263-2
R101, R106, R107, R108, R109, R301, R401, R501, R601: 2k; R_0603_1608Metric
R102, R103, R104, R105, R110, R111, R303, R403, R503, R603: 10k; R_0603_1608Metric
R302, R402, R502, R602: 220R; R_0603_1608Metric
R304, R404, R504, R604: 1k; R_0603_1608Metric
R305, R405, R505, R605: 0.002ohm/3W; D_2512_Shunt
R306, R307, R406, R407, R506, R507, R606, R607: 10R; R_0603_1608Metric
U101: ATtiny1614-SSNR; SOIC-14_3.9x8.7mm_P1.27mm
U102: ISO1540; SOIC-8_3.9x4.9mm_P1.27mm
U103, U701: RCLAMP0524P-N; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
U301, U401, U501, U601: INA226AIDGSR; VSSOP-10_3x3mm_P0.5mm
U702: H7533-H#; SOT-23

Connections:
+3V3: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C703.1, J103.4, R102.1, R103.1, R104.1, R105.1, R110.1, R111.1, U101.1, U102.8, U301.6, U401.1, U401.6, U501.6, U601.6, U702.2
/ASEL: J103.1, J103.3, J103.5, J103.7, U101.13, U301.2, U401.2, U501.2, U601.2
/DRVOUT_01: J101.2, J107.2, R305.3, R305.4, R307.2, U701.2, U701.9
/DRVOUT_02: J101.4, J108.2, R405.3, R405.4, R407.2, U701.5, U701.6
/DRVOUT_03: J102.2, J110.2, R505.3, R505.4, R507.2, U103.2, U103.9
/DRVOUT_04: J102.4, J111.2, R605.3, R605.4, R607.2, U103.5, U103.6
/DRVPWR_01: J101.1, Q302.3, R303.1, U301.8
/DRVPWR_02: J101.3, Q402.3, R403.1, U401.8
/DRVPWR_03: J102.1, Q502.3, R503.1, U501.8
/DRVPWR_04: J102.3, Q602.3, R603.1, U601.8
/FET01/VOUT: D302.1, Q302.2, R305.1, R305.2, R306.1
/FET02/VOUT: D402.1, Q402.2, R405.1, R405.2, R406.1
/FET03/VOUT: D502.1, Q502.2, R505.1, R505.2, R506.1
/FET04/VOUT: D602.1, Q602.2, R605.1, R605.2, R606.1
/FETDRIVE_01: R301.1, R302.2, U101.7
/FETDRIVE_02: R401.1, R402.2, U101.11
/FETDRIVE_03: R501.1, R502.2, U101.12
/FETDRIVE_04: R601.1, R602.2, U101.2
/Power-Input/Vin: F701.2, J701.1, J702.1
/Power-Input/Vin_fused: C702.1, D701.1, D703.2, FB701.1
/Power-Input/Vin_protected: C701.1, D703.1, J703.2, U702.3
/SCL: J103.8, R111.2, U101.9, U102.6, U301.5, U401.5, U501.5, U601.1, U601.5
/SCL_CONN: J106.4, J109.4, U102.3
/SDA: J103.6, R110.2, U101.8, U102.7, U301.4, U401.4, U501.1, U501.4, U601.4
/SDA_CONN: J106.3, J109.3, U102.2
/SWIN_1: J107.1, R102.2, R106.2, U701.1, U701.10
/SWIN_2: J108.1, R103.2, R107.2, U701.4, U701.7
/SWIN_3: J110.1, R104.2, R108.2, U103.1, U103.10
/SWIN_4: J111.1, R105.2, R109.2, U103.4, U103.7
/SWITCH_01: C101.1, R106.1, U101.6
/SWITCH_02: C102.1, R107.1, U101.5
/SWITCH_03: C103.1, R108.1, U101.4
/SWITCH_04: C104.1, R109.1, U101.3
/UPDI_LED: J105.1, R101.1, U101.10
/VCC_CONN_3V3: J106.2, J109.2, U102.1
GND: C101.2, C102.2, C103.2, C104.2, C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C701.2, C702.2, C703.2, D101.1, D301.1, D302.2, D401.1, D402.2, D501.1, D502.2, D601.1, D602.2, D701.2, J103.2, J105.2, J107.3, J108.3, J110.3, J111.3, J701.2, J702.2, J703.1, Q301.2, Q401.2, Q501.2, Q601.2, U101.14, U102.5, U103.3, U103.8, U301.1, U301.7, U401.7, U501.7, U601.7, U701.3, U701.8, U702.1
GNDA: J106.1, J109.1, U102.4
unnamed: C301.1, R306.2, U301.9
unnamed: C301.2, R307.1, U301.10
unnamed: C401.1, R406.2, U401.9
unnamed: C401.2, R407.1, U401.10
unnamed: C501.1, R506.2, U501.9
unnamed: C501.2, R507.1, U501.10
unnamed: C601.1, R606.2, U601.9
unnamed: C601.2, R607.1, U601.10
unnamed: D101.2, R101.2
unnamed: D301.2, R301.2
unnamed: D401.2, R401.2
unnamed: D501.2, R501.2
unnamed: D601.2, R601.2
unnamed: F701.1, FB701.2
unnamed: Q301.1, R302.1
unnamed: Q301.3, R303.2, R304.2
unnamed: Q302.1, R304.1
unnamed: Q401.1, R402.1
unnamed: Q401.3, R403.2, R404.2
unnamed: Q402.1, R404.1
unnamed: Q501.1, R502.1
unnamed: Q501.3, R503.2, R504.2
unnamed: Q502.1, R504.1
unnamed: Q601.1, R602.1
unnamed: Q601.3, R603.2, R604.2
unnamed: Q602.1, R604.1

## Commit log

2020-12-28 Init commit
2020-12-29 ME MAX 22,5 3-3 layout outlines

Notices in the files:
SH-ESP32-PowerFET-DIN/SH-ESP32-PowerFET-DIN.kicad_pcb:
Sailor Hat for ESP32 is licensed under CC BY-SA 4.0.
